# Keil uVision project Project.uvprojx, settings and files
target TDC_feedback (6190000::V6.19::ARMCLANG)
  device: MM32F0141C6P MindMotion
  pack: MindMotion.MM32F0140_DFP.1.2.2
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Project.axf
  c flags: Optim=2 OneElfS=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=3
  c include: ..\Application;..\Drivers;..\STARTUP\core;..\STARTUP\Include;..\HAL_Lib\Inc;..\HAL_Lib\Src
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application
    ../Application/: main.c
  group HAL_Lib
    ../HAL_Lib/Src/: hal_adc.c hal_comp.c hal_crc.c hal_dbg.c hal_div.c hal_dma.c hal_exti.c hal_flash.c hal_gpio.c hal_i2c.c hal_iwdg.c hal_misc.c hal_pwr.c hal_rcc.c hal_spi.c hal_tim.c hal_uart.c hal_uid.c hal_ver.c hal_wwdg.c hal_flexcan.c
  group STARTUP
    ../STARTUP/: startup_mm32f0140_keil.s system_mm32f0140.c
